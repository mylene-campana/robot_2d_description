Commit message: Update script to new optimizer (icra2016), Expand floor

File: urdf/box.urdf (robot description, URDF)
Before this commit: robot box_obstacle, 7 links, 6 joints
Links:
- link l_object_floor: geometry visual box size=50 40 0.05
